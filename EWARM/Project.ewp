# IAR project Project.ewp, settings and files
configuration STM32F401xx (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xC ST STM32F401xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx; STM32F401xx; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\Fatfs12b; ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\CIR43L22; ..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\Libraries\STM32_USB_OTG_Driver\inc; ..\libmad; ..\libmad\msvc++
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration stm32f407xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; USE_USB_OTG_FS; F407Discovery
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  group CIR43L22
    ../CIR43L22/: CIR43L22.c CIR43L22.h
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Doc
    ./: readme.txt
  group EWARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s
    $EW_DIR$/arm/RTOS/SEGGER/ST/STM32F4/embOS_STM32F40G_Eval/DeviceSupport/: startup_stm32f40x.s
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
  group Fatfs/inc
    ../Fatfs12b/: diskio.h ff.h ffconf.h integer.h
  group Fatfs/src
    ../Fatfs12b/option/: cc936.c ccsbcs.c
    ../Fatfs12b/: diskio.c ff.c ff_gen_drv.c msd_diskio.c usbh_diskio.c
  group INC
    ../inc/: board_init.h file_test.h main.h perip_func.h sdCard.h sendAno.h stm32f4xx_conf.h stm32f4xx_it.h
  group LIBMAD/INC
    ../libmad/: bit.h decoder.h fixed.h frame.h global.h huffman.h layer12.h layer3.h mad.h stream.h synth.h timer.h version.h
  group LIBMAD/SRC
    ../libmad/: bit.c decoder.c fixed.c frame.c huffman.c layer12.c layer3.c minimad.c stream.c synth.c timer.c version.c
  group STM32_USB_HOST_Library/CLASS/MSC
    ../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group STM32_USB_HOST_Library/CORE
    ../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group STM32_USB_OTG_Driver
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../: board_init.c bstdfile.c file_test.c madlld.c main.c perip_func.c perip_Systick.c sdCard.c sendAno.c stm32f4xx_it.c usb_bsp.c usbh_usr.c
    ../Fatfs12b/: player.c
