<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM32F401xx</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>stm32f407xx</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CIR43L22</name>
    <file>
      <name>$PROJ_DIR$\..\CIR43L22\CIR43L22.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CIR43L22\CIR43L22.h</name>
    </file>
  </group>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\system_stm32f4xx.c</name>
    </file>
  </group>
  <group>
    <name>Doc</name>
    <file>
      <name>$PROJ_DIR$\readme.txt</name>
    </file>
  </group>
  <group>
    <name>EWARM</name>
    <file>
      <name>$PROJ_DIR$\..\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm\startup_stm32f401xx.s</name>
    </file>
    <file>
      <name>$EW_DIR$\arm\RTOS\SEGGER\ST\STM32F4\embOS_STM32F40G_Eval\DeviceSupport\startup_stm32f40x.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f40xx.s</name>
    </file>
  </group>
  <group>
    <name>Fatfs</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\Fatfs12b\diskio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fatfs12b\ff.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fatfs12b\ffconf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fatfs12b\integer.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\Fatfs12b\option\cc936.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fatfs12b\option\cc949.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fatfs12b\option\ccsbcs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fatfs12b\diskio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fatfs12b\ff.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fatfs12b\ff_gen_drv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fatfs12b\msd_diskio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fatfs12b\usbh_diskio.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>INC</name>
    <file>
      <name>$PROJ_DIR$\..\inc\board_init.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\inc\file_test.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\inc\main.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\inc\perip_func.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\inc\sdCard.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\inc\sendAno.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\inc\stm32f4xx_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\inc\stm32f4xx_it.h</name>
    </file>
  </group>
  <group>
    <name>LIBMAD</name>
    <group>
      <name>INC</name>
      <file>
        <name>$PROJ_DIR$\..\libmad\bit.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\decoder.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\fixed.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\frame.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\global.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\huffman.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\layer12.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\layer3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\mad.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\stream.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\synth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\timer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\version.h</name>
      </file>
    </group>
    <group>
      <name>SRC</name>
      <file>
        <name>$PROJ_DIR$\..\libmad\bit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\decoder.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\fixed.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\frame.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\huffman.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\layer12.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\layer3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\minimad.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\stream.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\synth.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libmad\version.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>STM32_USB_HOST_Library</name>
    <group>
      <name>CLASS</name>
      <group>
        <name>MSC</name>
        <file>
          <name>$PROJ_DIR$\..\Libraries\STM32_USB_HOST_Library\Class\MSC\src\usbh_msc_bot.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Libraries\STM32_USB_HOST_Library\Class\MSC\src\usbh_msc_core.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Libraries\STM32_USB_HOST_Library\Class\MSC\src\usbh_msc_fatfs.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Libraries\STM32_USB_HOST_Library\Class\MSC\src\usbh_msc_scsi.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>CORE</name>
      <file>
        <name>$PROJ_DIR$\..\Libraries\STM32_USB_HOST_Library\Core\src\usbh_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Libraries\STM32_USB_HOST_Library\Core\src\usbh_hcs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Libraries\STM32_USB_HOST_Library\Core\src\usbh_ioreq.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Libraries\STM32_USB_HOST_Library\Core\src\usbh_stdreq.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>STM32_USB_OTG_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32_USB_OTG_Driver\src\usb_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32_USB_OTG_Driver\src\usb_hcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32_USB_OTG_Driver\src\usb_hcd_int.c</name>
    </file>
  </group>
  <group>
    <name>STM32F4xx_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_des.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_tdes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dcmi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma2d.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dsi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash_ramfunc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_fmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_fmpi2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_md5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_sha1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_lptim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_ltdc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_qspi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rng.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sai.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spdifrx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\board_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\bstdfile.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\file_test.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\madlld.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\perip_func.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\perip_Systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Fatfs12b\player.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\sdCard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\sendAno.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm32f4xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\usb_bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\usbh_usr.c</name>
    </file>
  </group>
</project>


